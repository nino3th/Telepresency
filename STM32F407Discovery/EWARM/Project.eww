<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F407Discovery.ewp</path>
  </project>
  <batchBuild />
</workspace>
